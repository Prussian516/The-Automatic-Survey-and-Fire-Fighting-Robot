# Keil uVision project Project.uvprojx, settings and files
target PROJECT (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\User;..\DRV\system;..\DRV\SysTick;..\DRV\delay;..\DRV\usart;..\DRV\NVIC;..\DRV\GPIO;..\DRV\TIM;..\HARDWARE\MOTO;..\DRV
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DRV
    ../DRV/system/: bsp_sys.c
    ../DRV/delay/: delay.c
    ../DRV/GPIO/: bsp_GPIO.c
    ../DRV/TIM/: bsp_timer8.c
    ../DRV/usart/: bsp_usart.c
  group HARDWARE
    ../HARDWARE/MOTO/: moto.c find.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group DOC
    ../Doc/: readme.txt
